FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-4.1:"

SRC_URI += "file://use_mainline_rtlwifi.patch"

